options:
  parameters:
    generate_options: qt_gui
    id: histogram_noisegen2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: hmax
  id: variable
  parameters:
    value: '3'
  states: {}
- name: hmin
  id: variable
  parameters:
    value: '-3'
  states: {}
- name: nbins
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: scale
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: amplitude
    noise_type: analog.GR_UNIFORM
    samples: '65536'
    seed: '0'
    type: float
  states: {}
- name: analog_fastnoise_source_x_1
  id: analog_fastnoise_source_x
  parameters:
    amp: amplitude
    noise_type: analog.GR_UNIFORM
    samples: '65536'
    seed: '1'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: scale
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
    vlen: nbins
  states: {}
- name: openemissions_histogram_0
  id: openemissions_histogram
  parameters:
    input_type: Float
    max: hmax
    min: hmin
    nbuckets: nbins
    output_type: Float
    prop_tag_keys: ''
    vinlen: '1'
  states: {}
- name: openemissions_histogram_1
  id: openemissions_histogram
  parameters:
    input_type: Float
    max: hmax
    min: hmin
    nbuckets: nbins
    output_type: Float
    prop_tag_keys: ''
    vinlen: '1'
  states: {}
- name: openemissions_histogram_solve_0
  id: openemissions_histogram_solve
  parameters:
    expr: x1 * x2
    extrema: (x1,0),(0,x2),(0,0)
    freq_type: Float
    max: hmax
    min: hmin
    nbuckets: nbins
    nvars: '2'
    unknown: x1
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: nbins
    x_start: hmin + 0*(hmax-hmin)/2/nbins
    x_step: (hmax-hmin)/nbins
    ymax: '0.001'
    ymin: '-0.001'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    nconnections: '2'
    vlen: nbins
    x_start: hmin + 0*(hmax-hmin)/2/nbins
    x_step: (hmax-hmin)/nbins
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_multiply_const_xx_0, '0']
- [analog_fastnoise_source_x_1, '0', openemissions_histogram_0, '0']
- [blocks_multiply_const_xx_0, '0', openemissions_histogram_1, '0']
- [blocks_throttle_1, '0', qtgui_vector_sink_f_0, '0']
- [openemissions_histogram_0, '0', openemissions_histogram_solve_0, '1']
- [openemissions_histogram_0, '0', qtgui_vector_sink_f_1, '1']
- [openemissions_histogram_1, '0', openemissions_histogram_solve_0, '0']
- [openemissions_histogram_1, '0', qtgui_vector_sink_f_1, '0']
- [openemissions_histogram_solve_0, '0', blocks_throttle_1, '0']

metadata:
  file_format: 1
