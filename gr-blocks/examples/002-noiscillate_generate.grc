options:
  parameters:
    generate_options: qt_gui
    id: noiscillate_generate
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '40'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: openemissions_pigpio_sink_0
  id: openemissions_pigpio_sink
  parameters:
    address: 169.254.237.219:8888
    hardware_clock_frequency: '30000000'
    level: '0'
    pad_milliamps: '0'
    pin: '4'
    samples_per_second: samp_rate
    type: float
    vlen: '1'
    wave_buffer_percent: '25'
  states: {}

connections:
- [analog_sig_source_x_0, '0', openemissions_pigpio_sink_0, '0']

metadata:
  file_format: 1
