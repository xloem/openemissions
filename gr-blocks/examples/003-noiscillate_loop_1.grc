options:
  parameters:
    generate_options: qt_gui
    id: noiscillate_loop_1
    output_language: python
    title: Noiscillate Packet Waterfall
  states: {}

blocks:
- name: gain_control
  id: variable_qtgui_dial_control
  parameters:
    label: Gain (dB)
    maximum: '50'
    minimum: '0'
    outputmsgname: gain_control
    showvalue: 'True'
    type: int
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sig_len
  id: variable
  parameters:
    value: int(samp_rate / sig_rate + 0.5)
  states: {}
- name: sig_rate
  id: variable_qtgui_range
  parameters:
    label: Packet Frequency
    start: '30'
    step: sig_len / samp_rate / 10
    stop: '50'
    value: '40'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '40'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: mag^2 because the source is random
  states: {}
- name: openemissions_pigpio_sink_0
  id: openemissions_pigpio_sink
  parameters:
    address: 169.254.237.219:8888
    hardware_clock_frequency: '30000000'
    level: '0'
    pad_milliamps: '0'
    pin: '4'
    samples_per_second: samp_rate
    type: float
    vlen: '1'
    wave_buffer_percent: '50'
  states: {}
- name: qtgui_auto_correlator_sink_0
  id: qtgui_auto_correlator_sink
  parameters:
    fac_decimation: '1'
    fac_size: sig_len * 4
    sampRate: samp_rate
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: sig_len
    nrows: '256'
    samp_rate: samp_rate
    type: float
    update_time: '0'
    zmin: '0'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: 100e6
    gain0: gain_control
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', openemissions_pigpio_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_raster_sink_x_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', qtgui_auto_correlator_sink_0, '0']

metadata:
  file_format: 1
