options:
  parameters:
    generate_options: qt_gui
    id: noiscillate_loop_1
    output_language: python
    title: Noiscillate Packet Waterfall
  states: {}

blocks:
- name: gain_control
  id: variable_qtgui_dial_control
  parameters:
    label: Gain (dB)
    maximum: '50'
    minimum: '0'
    outputmsgname: gain_control
    showvalue: 'True'
    type: int
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sig_len
  id: variable
  parameters:
    value: int(samp_rate / sig_rate + 0.5)
  states: {}
- name: sig_rate
  id: variable_qtgui_range
  parameters:
    label: Packet Frequency
    start: '70'
    step: sig_len / samp_rate / 10
    stop: '90'
    value: '80'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '80'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: mag^2 because the source is random
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: sig_len
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(2048)
  states: {state: disabled}
- name: openemissions_pigpio_sink_0
  id: openemissions_pigpio_sink
  parameters:
    address: 169.254.237.219:8888
    hardware_clock_frequency: '30000000'
    level: '0'
    pad_milliamps: '0'
    pin: '4'
    samples_per_second: samp_rate
    type: float
    vlen: '1'
    wave_buffer_percent: '25'
  states: {}
- name: qtgui_auto_correlator_sink_0
  id: qtgui_auto_correlator_sink
  parameters:
    fac_decimation: int(sig_len/16)
    fac_size: sig_len * sig_len
    sampRate: samp_rate
  states: {}
- name: qtgui_auto_correlator_sink_1
  id: qtgui_auto_correlator_sink
  parameters:
    fac_decimation: '1'
    fac_size: '2048'
    sampRate: samp_rate/256
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/256
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: sig_len
    nrows: '256'
    samp_rate: samp_rate
    type: float
    update_time: '0'
    zmin: '0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    update_time: '0.1'
    vlen: sig_len
    x_start: '0'
    x_step: '1.0'
    ymax: '2'
    ymin: '0'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '1'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '1'
    type: fff
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: 100e6
    gain0: gain_control
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', openemissions_pigpio_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', rational_resampler_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_auto_correlator_sink_1, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_stream_to_vector_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', blocks_null_sink_0, '0']
- [rtlsdr_source_0, '0', qtgui_auto_correlator_sink_0, '0']

metadata:
  file_format: 1
