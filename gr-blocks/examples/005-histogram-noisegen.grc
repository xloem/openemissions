options:
  parameters:
    generate_options: qt_gui
    id: histogram_noisegen
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ampl_bg
  id: variable
  parameters:
    value: '0.75'
  states: {}
- name: ampl_fg
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: nbuckets
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: vmax
  id: variable
  parameters:
    value: (ampl_fg**2 + ampl_bg**2)*2
  states: {}
- name: vmin
  id: variable
  parameters:
    value: '-vmax'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: ampl_bg
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: ampl_fg
    noise_type: analog.GR_UNIFORM
    seed: '1'
    type: complex
  states: {}
- name: analog_noise_source_x_2
  id: analog_noise_source_x
  parameters:
    alias: BG
    amp: ampl_bg
    noise_type: analog.GR_GAUSSIAN
    seed: '3'
    type: complex
  states: {}
- name: analog_noise_source_x_3
  id: analog_noise_source_x
  parameters:
    amp: ampl_fg
    noise_type: analog.GR_UNIFORM
    seed: '2'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: openemissions_histogram_0
  id: openemissions_histogram
  parameters:
    input_type: Float
    max: vmax
    min: vmin
    nbuckets: nbuckets
    output_type: Float
    prop_tag_keys: ''
    vinlen: '1'
  states: {}
- name: openemissions_histogram_1
  id: openemissions_histogram
  parameters:
    input_type: Float
    max: vmax
    min: vmin
    nbuckets: nbuckets
    output_type: Float
    prop_tag_keys: ''
    vinlen: '1'
  states: {}
- name: openemissions_histogram_2
  id: openemissions_histogram
  parameters:
    input_type: Float
    max: vmax
    min: vmin
    nbuckets: nbuckets
    output_type: Float
    prop_tag_keys: ''
    vinlen: '1'
  states: {}
- name: openemissions_histogram_3
  id: openemissions_histogram
  parameters:
    input_type: Float
    max: vmax
    min: vmin
    nbuckets: nbuckets
    output_type: Float
    prop_tag_keys: ''
    vinlen: '1'
  states: {}
- name: openemissions_histogram_solve_0
  id: openemissions_histogram_solve
  parameters:
    expr: x1 - x2
    freq_type: Float
    max: vmax
    min: vmin
    nbuckets: nbuckets
    nvars: '2'
    output_idx: '0'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.2'
    color3: '"dark blue"'
    label1: BG Noise
    label2: FG Noise
    label3: Summed Noise
    label4: Prehist Summed - BG
    nconnections: '4'
    vlen: nbuckets
    x_axis_label: Signal
    x_start: vmin
    x_step: (vmax - vmin) / nbuckets
    y_axis_label: Frequency
    ymax: '0.01'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    label1: Posthist Summed - BG
    vlen: nbuckets
    x_start: vmin
    x_step: (vmax - vmin) / nbuckets
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_2, '0', blocks_complex_to_mag_squared_1, '0']
- [analog_noise_source_x_3, '0', blocks_complex_to_mag_squared_2, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_throttle_1, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_2, '0', blocks_throttle_2, '0']
- [blocks_sub_xx_0, '0', openemissions_histogram_3, '0']
- [blocks_throttle_0, '0', blocks_sub_xx_0, '1']
- [blocks_throttle_0, '0', openemissions_histogram_1, '0']
- [blocks_throttle_1, '0', blocks_sub_xx_0, '0']
- [blocks_throttle_1, '0', openemissions_histogram_0, '0']
- [blocks_throttle_2, '0', openemissions_histogram_2, '0']
- [openemissions_histogram_0, '0', openemissions_histogram_solve_0, '0']
- [openemissions_histogram_0, '0', qtgui_vector_sink_f_0, '2']
- [openemissions_histogram_1, '0', openemissions_histogram_solve_0, '1']
- [openemissions_histogram_1, '0', qtgui_vector_sink_f_0, '0']
- [openemissions_histogram_2, '0', qtgui_vector_sink_f_0, '1']
- [openemissions_histogram_3, '0', qtgui_vector_sink_f_0, '3']
- [openemissions_histogram_solve_0, '0', qtgui_vector_sink_f_1, '0']

metadata:
  file_format: 1
