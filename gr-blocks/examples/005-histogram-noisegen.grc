options:
  parameters:
    generate_options: qt_gui
    id: histogram_noisegen
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ampl_bg
  id: variable
  parameters:
    value: '0.75'
  states: {}
- name: ampl_fg
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: nbuckets
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: vmax
  id: variable
  parameters:
    value: (ampl_fg**2 + ampl_bg**2)**.5*8
  states: {}
- name: vmin
  id: variable
  parameters:
    value: '-vmax'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: ampl_bg
    noise_type: analog.GR_LAPLACIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: ampl_fg
    noise_type: analog.GR_UNIFORM
    seed: '1'
    type: float
  states: {}
- name: analog_noise_source_x_2
  id: analog_noise_source_x
  parameters:
    amp: ampl_bg
    noise_type: analog.GR_LAPLACIAN
    seed: '3'
    type: float
  states: {}
- name: analog_noise_source_x_3
  id: analog_noise_source_x
  parameters:
    amp: ampl_fg
    noise_type: analog.GR_UNIFORM
    seed: '2'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: nbuckets
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: openemissions_histogram_0
  id: openemissions_histogram
  parameters:
    input_type: Float
    max: vmax
    min: vmin
    nbuckets: nbuckets
    output_type: Float
    prop_tag_keys: ''
    vinlen: '1'
  states: {}
- name: openemissions_histogram_1
  id: openemissions_histogram
  parameters:
    input_type: Float
    max: vmax
    min: vmin
    nbuckets: nbuckets
    output_type: Float
    prop_tag_keys: ''
    vinlen: '1'
  states: {}
- name: openemissions_histogram_2
  id: openemissions_histogram
  parameters:
    input_type: Float
    max: vmax
    min: vmin
    nbuckets: nbuckets
    output_type: Float
    prop_tag_keys: ''
    vinlen: '1'
  states: {}
- name: openemissions_histogram_3
  id: openemissions_histogram
  parameters:
    input_type: Float
    max: vmax
    min: vmin
    nbuckets: nbuckets
    output_type: Float
    prop_tag_keys: ''
    vinlen: '1'
  states: {}
- name: openemissions_histogram_binary_op_0
  id: openemissions_histogram_binary_op
  parameters:
    freq_type: Float
    max: vmax
    min: vmin
    nbuckets: nbuckets
    op: x - y
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    color3: '"dark blue"'
    grid: 'True'
    label1: BG Noise
    label2: FG Noise
    label3: Summed Noise
    label4: Prehist Summed - BG
    label5: Posthist Summed - BG
    nconnections: '5'
    vlen: nbuckets
    x_axis_label: Signal
    x_start: vmin
    x_step: (vmax - vmin) / nbuckets
    y_axis_label: Frequency
    ymax: '0.01'
    ymin: '0'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_2, '0', blocks_complex_to_mag_squared_1, '0']
- [analog_noise_source_x_2, '0', blocks_throttle_0, '0']
- [analog_noise_source_x_3, '0', blocks_complex_to_mag_squared_2, '0']
- [analog_noise_source_x_3, '0', blocks_throttle_2, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_throttle_1, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_2, '0', blocks_throttle_2, '0']
- [blocks_sub_xx_0, '0', openemissions_histogram_3, '0']
- [blocks_throttle_0, '0', blocks_sub_xx_0, '1']
- [blocks_throttle_0, '0', openemissions_histogram_1, '0']
- [blocks_throttle_1, '0', blocks_sub_xx_0, '0']
- [blocks_throttle_1, '0', openemissions_histogram_0, '0']
- [blocks_throttle_2, '0', openemissions_histogram_2, '0']
- [openemissions_histogram_0, '0', openemissions_histogram_binary_op_0, '0']
- [openemissions_histogram_0, '0', qtgui_vector_sink_f_0, '2']
- [openemissions_histogram_1, '0', openemissions_histogram_binary_op_0, '1']
- [openemissions_histogram_1, '0', qtgui_vector_sink_f_0, '0']
- [openemissions_histogram_2, '0', qtgui_vector_sink_f_0, '1']
- [openemissions_histogram_3, '0', qtgui_vector_sink_f_0, '3']
- [openemissions_histogram_binary_op_0, '0', qtgui_vector_sink_f_0, '4']

metadata:
  file_format: 1
